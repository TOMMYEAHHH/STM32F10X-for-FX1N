#include "fx1nhelper.h"

static const u8t ascii[16] = "0123456789ABCDEF";
static const u8t asciivalues[256] = {
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //10
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //20
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //30
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //40
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,  //50
    0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0xFF, 0xFF,  //60
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E,  //70
    0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //80
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //90
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //100
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //110
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //120
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //130
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //140
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //150
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //160
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //170
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //180
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //190
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //200
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //210
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //220
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //230
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //240
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,  //250
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF                          
};
u32t hextoasc(u8t data) {
    u32t l1;
    u32t l2;

    l1 = ascii[data & 0x0f];
    l2 = ascii[(data >> 4) & 0x0f];
    l2 <<= 8;
    return l1 | l2;
}
u8t asctohex(u8t *buf) {
    return (asciivalues[buf[0]] << 4) | asciivalues[buf[1]];
}
u8t ascto0F(u8t data) {
    return asciivalues[data];
    /*u8t t = asciivalues[data];
    
    if (t == 0xFF) {
        while(1) {
            //err
        }
    }
    return t;*/
}

void plcvm_set_run(void) {
    //
}
void plcvm_set_stop(void) {
    //
}
s32t str_cmp(const u8t *s, const u8t *d, u32t length) {
    s32t r;
    while(length-- > 0) {
        r = (s32t)(*s++) - (s32t)(*d++);
        if (r != 0) {
            return r;
        }
    }
    return 0;
}
void str_copy(const u8t *s, u8t *d, u32t length) {
    while(length-- > 0) {
        *d++ = *s++;
    }
}
void str_clr(u8t *s, u32t length) {
    u32t i;
    for (i = 0; i< length; i++) {
        *s++ = 0;
    }
}
void str_set_bit(u8t *s, u32t index) {
    s += (index / 8);
    *s |= (1 << (index % 8));
}
void u8t_bit_reverse(u8t *d, u32t i) {
    u8t a = *d;
    u8t b;

    i = 0x01 << i;
    b = ~a & i;
    a = a & ~i;
    *d = a | b;
}

void u8t_bit_set_one(u8t *d, u32t i) {
    i = 0x01 << i;
    *d |= i;
}
void u8t_bit_set_zero(u8t *d, u32t i) {
    i = 0x01 << i;
    i = ~i;
    *d &= i;
}
/*
void u8t_bit_set(u8t *d, u32t mask, u32t v) {
    u32t t;

    t = *d;
    t &= ~mask;
    v = mask & v;
    t |= v;
    *d = t;
}*/
/*
u32t u32t_bit_get(u32t d, u32t i) {
    i = 0x01 << i;
    return (d & i) ? 1 : 0;
}

s32t search(const u32t *oid, u32t len) {
    s32t num = 0;
    s32t num2 = (0 + CTX_ROWS_CNT) - 1;
    s32t num3;
    s32t num4;
    s32t t;

    while (num <= num2) {
        t = (num2 - num);
        t >>= 1;
        num3 = num + t;
        num4 = snmp_oidcompare(snmpData[num3].oid, snmpData[num3].oidlen, oid, len);
        if (num4 == 0) {
            return num3;
        }
        if (num4 < 0) {
            num = num3 + 1;
        }
        else {
            num2 = num3 - 1;
        }
    }
    return ~num;
}*/
