# Keil uVision project ppiapp.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ppiapp +hex
  AfterMake: fromelf.exe --bin -o./Objects/ppiapp.bin ./Objects/ppiapp.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\core;.\src;.\fwlib\inc;.\fx1n
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: main.c stm32f10x_it.c system_stm32f10x.c SysTick.c port_a.asm sio.c
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group core
    ./core/: core_cm3.c startup_stm32f10x_md.s
  group fx1n
    ./fx1n/: fx1nhelper.c FX1N.c fx1nfnc.c fx1niap.c fx1nuart.c
